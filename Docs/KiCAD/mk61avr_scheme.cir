* EESchema Netlist Version 1.1 (Spice format) creation date: Вт 17 янв 2017 16:00:49

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
R1  N-000022 /ROW_3 680
SW17  N-000022 /COL_4 LOAD
SW13  N-000022 /COL_3 SAVE
SW9  N-000022 /COL_2 RGT
SW5  N-000022 /COL_1 LFT
SW1  N-000022 /COL_0 ON/OFF
R4  N-000021 /ROW_2 680
R3  N-000001 /ROW_1 680
R2  N-000023 /ROW_0 680
SW35  N-000021 /COL_9 F
SW34  N-000001 /COL_9 Bx
SW33  N-000023 /COL_9 9
SW32  N-000021 /COL_8 K
SW31  N-000001 /COL_8 Cx
SW30  N-000023 /COL_8 8
SW29  N-000021 /COL_7 <STEP
SW28  N-000001 /COL_7 POW
SW27  N-000023 /COL_7 7
SW26  N-000021 /COL_6 LOAD
SW25  N-000001 /COL_6 /-/
SW24  N-000023 /COL_6 6
SW23  N-000021 /COL_5 STEP>
SW22  N-000001 /COL_5 ,
SW21  N-000023 /COL_5 5
SW20  N-000021 /COL_4 STORE
SW19  N-000001 /COL_4 XY
SW18  N-000023 /COL_4 4
SW16  N-000021 /COL_3 SUB
SW15  N-000001 /COL_3 3
SW14  N-000023 /COL_3 3
SW12  N-000021 /COL_2 RET
SW11  N-000001 /COL_2 X
SW10  N-000023 /COL_2 2
SW8  N-000021 /COL_1 GOTO
SW7  N-000001 /COL_1 -
SW6  N-000023 /COL_1 1
SW4  N-000021 /COL_0 S/S
SW3  N-000001 /COL_0 +
SW2  N-000023 /COL_0 0
IC1  N-000012 /RX /TX /ROW_0 /ROW_1 /ROW_2 VCC GND /COL_6 /COL_7 /ROW_3 ? ? /COL_0 /COL_1 /COL_2 /COL_3 /COL_4 /COL_5 VCC ? GND /COL_8 /COL_9 ? ? /I2C_SDA /I2C_SCL ATMEGA8-P
P1  VCC /I2C_SDA /I2C_SCL GND CONN_4
K1  GND /RX /TX CONN_3
SW36  GND N-000012 SW_PUSH

.end
